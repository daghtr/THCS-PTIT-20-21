# Keil uVision project BTL.uvprojx, settings and files
target BTL (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Dust +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Project;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;D:\STM32\Lib_LCD16X2;D:\STM32\Lib_delay;.\User_STM32;.\LIB_LAB\irc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_i2c.c
  group user
    ./Project/: main.c stm32f10x_it.c system_stm32f10x.c
  group LCD 20x4
    ./LIB_LAB/src/: mcu-delay.c
    ./User_STM32/: mcu-i2c.c mcu-i2c-lcd.c
